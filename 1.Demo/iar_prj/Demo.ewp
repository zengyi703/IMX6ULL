# IAR project Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX6Y2 NXP MCIMX6Y2
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: CPU_MCIMX6Y2DVM05; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../board; ../start; ../drivers; ../app
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Demo.bin
  ILINK.IlinkOutputFile: Demo.out
  ILINK.IlinkIcfFile: D:\MyWork\1.项目文件\Iar\MCIMX6ULL\2.led_test\iar_prj\MCIMX6Y2xxx05_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../app/: main.c
  group board
    ../board/: board.c board.h delay.c delay.h key.c key.h led.c led.h timer.c timer.h uart.c uart.h
  group driver
    ../drivers/: fsl_clock.c fsl_clock.h fsl_epit.c fsl_epit.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_uart.c fsl_uart.h
  group start
    ../start/: startup_MCIMX6Y2.s system_MCIMX6Y2.c system_MCIMX6Y2.h
