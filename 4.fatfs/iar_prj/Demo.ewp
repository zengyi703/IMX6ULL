# IAR project Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX6Y2 NXP MCIMX6Y2
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: CPU_MCIMX6Y2DVM05; _DLIB_FILE_DESCRIPTOR; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../board; ../start; ../drivers; ../app; ../sdmmc/inc; ../sdmmc/port; ../fatfs/src; ../fatfs/src/fsl_sd_disk
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Demo.bin
  ILINK.IlinkOutputFile: Demo.out
  ILINK.IlinkIcfFile: D:\MyWork\1.项目文件\Iar\MCIMX6ULL\new\3.sdcard\iar_prj\MCIMX6Y2xxx05_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../app/: main.c
  group board
    ../board/: board.c delay.c key.c led.c sdcard.c uart.c
  group driver
    ../drivers/: fsl_cache.c fsl_clock.c fsl_epit.c fsl_gpio.c fsl_uart.c fsl_usdhc.c
  group fatfs/inc
    ../fatfs/src/: diskio.h ff.h integer.h
    ../fatfs/src/fsl_sd_disk/: fsl_sd_disk.h
  group fatfs/src
    ../fatfs/src/: diskio.c ff.c
    ../fatfs/src/fsl_sd_disk/: fsl_sd_disk.c
  group sdmmc/inc
    ../sdmmc/inc/: fsl_card.h fsl_host.h fsl_sdmmc.h fsl_specification.h
  group sdmmc/port
    ../sdmmc/port/usdhc/interrupt/: event.c fsl_host.c
    ../sdmmc/port/: event.h
  group sdmmc/src
    ../sdmmc/src/: fsl_sd.c fsl_sdmmc.c
  group start
    ../start/: startup_MCIMX6Y2.s system_MCIMX6Y2.c
